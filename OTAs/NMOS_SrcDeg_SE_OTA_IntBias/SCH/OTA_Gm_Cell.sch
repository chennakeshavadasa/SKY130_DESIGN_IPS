v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {~500nA} 500 -100 0 0 0.4 0.4 {}
T {~500nA} 770 -100 0 0 0.4 0.4 {}
T {~500nA} 1010 -100 0 0 0.4 0.4 {}
T {~500nA} 250 -100 0 0 0.4 0.4 {}
N 810 -460 810 -350 {lab=MN_TAIL_BIAS}
N 520 -460 520 -350 {lab=VBP_TOP}
N 520 -600 520 -520 {lab=#net1}
N 810 -600 810 -520 {lab=#net2}
N 520 -730 520 -660 {lab=AVDDH}
N 810 -730 810 -660 {lab=AVDDH}
N 520 -110 850 -110 {lab=GNDA}
N 810 -170 810 -110 {lab=GNDA}
N 620 -630 620 -420 {lab=VBP_TOP}
N 520 -420 620 -420 {lab=VBP_TOP}
N 1030 -460 1030 -350 {lab=VOUT}
N 1030 -600 1030 -520 {lab=#net3}
N 1030 -730 1030 -660 {lab=AVDDH}
N 810 -730 1030 -730 {lab=AVDDH}
N 730 -320 770 -320 {lab=MN_TAIL_BIAS}
N 730 -380 730 -320 {lab=MN_TAIL_BIAS}
N 730 -380 810 -380 {lab=MN_TAIL_BIAS}
N 770 -320 990 -320 {lab=MN_TAIL_BIAS}
N 810 -290 810 -170 {lab=GNDA}
N 770 -490 990 -490 {lab=VBP_CASC}
N 770 -630 990 -630 {lab=VBP_TOP}
N 850 -110 1030 -110 {lab=GNDA}
N 520 -730 810 -730 {lab=AVDDH}
N 560 -630 620 -630 {lab=VBP_TOP}
N 620 -630 770 -630 {lab=VBP_TOP}
N 560 -490 770 -490 {lab=VBP_CASC}
N 1260 -600 1260 -520 {lab=#net4
}
N 1260 -730 1260 -660 {lab=AVDDH
}
N 1260 -460 1260 -360 {lab=VSTRP_IP
}
N 1330 -370 1430 -370 {lab=EN
}
N 520 -290 520 -250 {lab=#net5}
N 1030 -290 1030 -250 {lab=#net6}
N 1030 -150 1030 -110 {lab=GNDA}
N 1060 -200 1060 -110 {lab=GNDA}
N 270 -730 270 -660 {lab=AVDDH}
N 270 -290 270 -110 {lab=GNDA}
N 270 -460 270 -430 {lab=VBP_CASC}
N 270 -660 270 -520 {lab=AVDDH}
N 270 -430 270 -350 {lab=VBP_CASC}
N 270 -420 350 -420 {lab=VBP_CASC}
N 310 -490 350 -490 {lab=VBP_CASC}
N 270 -730 520 -730 {lab=AVDDH}
N 270 -110 520 -110 {lab=GNDA}
N 560 -320 730 -320 {lab=MN_TAIL_BIAS}
N 310 -320 560 -320 {lab=MN_TAIL_BIAS}
N 1260 -250 1260 -220 {lab=GNDA
}
N 1630 -730 1630 -690 {lab=AVDDH
}
N 1260 -730 1310 -730 {lab=AVDDH
}
N 1630 -590 1630 -420 {lab=#net7
}
N 1550 -390 1590 -390 {lab=VSTRP_OUT
}
N 1630 -360 1630 -320 {lab=MN_TAIL_BIAS
}
N 1260 -360 1260 -280 {lab=VSTRP_IP
}
N 1260 -220 1260 -110 {lab=GNDA
}
N 180 -730 270 -730 {lab=AVDDH}
N 180 -110 270 -110 {lab=GNDA}
N 1660 -640 1700 -640 {lab=GNDA
}
N 80 -180 80 -150 {lab=0}
N -20 -180 -20 -150 {lab=0}
N -20 -270 -20 -240 {lab=AVDDH}
N 80 -270 80 -240 {lab=GNDA}
N 170 -180 170 -150 {lab=0}
N 170 -270 170 -240 {lab=EN}
N 670 -730 670 -710 {lab=AVDDH}
N 670 -650 670 -630 {lab=VBP_TOP}
N 580 -680 630 -680 {lab=EN}
N 1380 -570 1410 -570 {lab=EN
}
N 1490 -570 1520 -570 {lab=EN_B
}
N 670 -320 670 -270 {lab=MN_TAIL_BIAS}
N 670 -210 670 -110 {lab=GNDA}
N 600 -240 630 -240 {lab=EN_B}
N 1030 -110 1060 -110 {lab=GNDA}
N 350 -490 350 -420 {lab=VBP_CASC}
N 660 -490 660 -460 {lab=VBP_CASC}
N 520 -150 520 -110 {lab=GNDA}
N 550 -200 550 -110 {lab=GNDA}
N 1410 -410 1430 -410 {lab=#net8}
N 1260 -410 1330 -410 {lab=VSTRP_IP}
N 1310 -730 1630 -730 {lab=AVDDH}
N 1170 -250 1210 -250 {lab=AVDDH}
N 1030 -410 1080 -410 {lab=VOUT}
N 990 -630 1220 -630 {lab=VBP_TOP}
N 990 -320 1630 -320 {lab=MN_TAIL_BIAS}
N 990 -490 1220 -490 {lab=VBP_CASC}
N 1030 -730 1260 -730 {lab=AVDDH}
N 1060 -110 1260 -110 {lab=GNDA}
N 1260 -110 1800 -110 {lab=GNDA
}
N 1800 -290 1800 -110 {lab=GNDA
}
N 1800 -730 1800 -680 {lab=AVDDH}
N 1630 -730 1800 -730 {lab=AVDDH}
N 1800 -620 1800 -350 {lab=VSCALE}
N 1840 -650 1880 -650 {lab=VSCALE}
N 1880 -650 1880 -590 {lab=VSCALE}
N 1800 -590 1880 -590 {lab=VSCALE}
N 1700 -320 1760 -320 {lab=MN_TAIL_BIAS}
N 1630 -320 1700 -320 {lab=MN_TAIL_BIAS}
N 1970 -290 1970 -110 {lab=GNDA
}
N 1970 -730 1970 -680 {lab=AVDDH}
N 1970 -620 1970 -350 {lab=#net9}
N 2010 -650 2050 -650 {lab=#net9}
N 2050 -650 2050 -590 {lab=#net9}
N 1970 -590 2050 -590 {lab=#net9}
N 1810 -730 1970 -730 {lab=AVDDH}
N 1800 -730 1810 -730 {lab=AVDDH}
N 1800 -110 1970 -110 {lab=GNDA}
N 1760 -320 1930 -320 {lab=MN_TAIL_BIAS}
N 2190 -720 2190 -680 {lab=AVDDH}
N 2190 -730 2190 -720 {lab=AVDDH}
N 1970 -730 2190 -730 {lab=AVDDH}
N 2130 -650 2150 -650 {lab=VSCALE}
N 2190 -620 2190 -350 {lab=#net10}
N 2120 -320 2150 -320 {lab=#net10}
N 2120 -380 2120 -320 {lab=#net10}
N 2120 -380 2190 -380 {lab=#net10}
N 2190 -290 2190 -120 {lab=GNDA}
N 2190 -120 2190 -110 {lab=GNDA}
N 1970 -110 2190 -110 {lab=GNDA}
N 2510 -320 2540 -320 {lab=#net11}
N 2540 -380 2540 -320 {lab=#net11}
N 2470 -380 2540 -380 {lab=#net11}
N 2470 -380 2470 -350 {lab=#net11}
N 2470 -290 2470 -110 {lab=GNDA}
N 2190 -110 2470 -110 {lab=GNDA}
N 2470 -520 2470 -380 {lab=#net11}
N 2470 -730 2470 -580 {lab=AVDDH}
N 2190 -730 2470 -730 {lab=AVDDH}
N 2540 -320 2620 -320 {lab=#net11}
N 2660 -290 2660 -110 {lab=GNDA}
N 2470 -110 2660 -110 {lab=GNDA}
N 2660 -600 2660 -350 {lab=#net12}
N 2660 -730 2660 -660 {lab=AVDDH}
N 2470 -730 2660 -730 {lab=AVDDH}
N 2700 -630 2780 -630 {lab=#net12}
N 2660 -570 2740 -570 {lab=#net12}
N 2740 -630 2740 -570 {lab=#net12}
N 3020 -730 3020 -660 {lab=AVDDH}
N 2860 -730 3020 -730 {lab=AVDDH}
N 3020 -600 3020 -350 {lab=#net13}
N 3020 -290 3020 -120 {lab=GNDA}
N 2660 -110 2820 -110 {lab=GNDA}
N 2660 -730 2860 -730 {lab=AVDDH}
N 2820 -110 3020 -110 {lab=GNDA}
N 3020 -120 3020 -110 {lab=GNDA}
N 2780 -630 2980 -630 {lab=#net12}
N 2880 -320 2980 -320 {lab=#net14}
N 2840 -290 2840 -110 {lab=GNDA}
N 2840 -730 2840 -500 {lab=AVDDH}
N 2840 -440 2840 -350 {lab=#net14}
N 2840 -390 2920 -390 {lab=#net14}
N 2920 -390 2920 -320 {lab=#net14}
N 3160 -480 3160 -350 {lab=#net13}
N 3020 -480 3160 -480 {lab=#net13}
N 3160 -290 3160 -110 {lab=GNDA}
N 3020 -110 3160 -110 {lab=GNDA}
N 3200 -320 3290 -320 {lab=#net13}
N 3160 -400 3220 -400 {lab=#net13}
N 3220 -400 3250 -400 {lab=#net13}
N 3250 -400 3250 -320 {lab=#net13}
N 3330 -290 3330 -120 {lab=GNDA}
N 3330 -120 3330 -110 {lab=GNDA}
N 3160 -110 3330 -110 {lab=GNDA}
N 3330 -590 3330 -350 {lab=#net15}
N 3330 -600 3330 -590 {lab=#net15}
N 3330 -730 3330 -660 {lab=AVDDH}
N 3020 -730 3330 -730 {lab=AVDDH}
N 3370 -630 3460 -630 {lab=#net15}
N 3500 -730 3500 -660 {lab=AVDDH}
N 3330 -730 3500 -730 {lab=AVDDH}
N 3330 -560 3410 -560 {lab=#net15}
N 3410 -630 3410 -560 {lab=#net15}
N 3330 -110 3500 -110 {lab=GNDA}
N 3610 -370 3680 -370 {lab=#net16}
N 3610 -370 3610 -320 {lab=#net16}
N 3740 -730 3740 -450 {lab=AVDDH}
N 3500 -730 3740 -730 {lab=AVDDH}
N 3610 -410 3680 -410 {lab=#net17}
N 3610 -540 3610 -410 {lab=#net17}
N 3890 -540 3890 -390 {lab=Vout_Final}
N 3830 -390 3890 -390 {lab=Vout_Final}
N 3890 -390 4000 -390 {lab=Vout_Final}
N 3820 -540 3890 -540 {lab=Vout_Final}
N 3610 -540 3760 -540 {lab=#net17}
N 3610 -320 3610 -260 {lab=#net16}
N 3610 -200 3610 -110 {lab=GNDA}
N 3500 -110 3610 -110 {lab=GNDA}
N 3740 -330 3740 -110 {lab=GNDA}
N 3620 -110 3740 -110 {lab=GNDA}
N 3610 -110 3620 -110 {lab=GNDA}
N 3500 -600 3500 -480 {lab=#net17}
N 3500 -480 3610 -480 {lab=#net17}
N 3940 -390 3940 -300 {lab=Vout_Final}
N 3940 -240 3940 -110 {lab=GNDA}
N 3740 -110 3940 -110 {lab=GNDA}
C {sky130_fd_pr/nfet3_01v8.sym} 540 -320 0 1 {name=M1
W=10
L=4
body=GND
nf=1
mult=16
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 540 -630 0 1 {name=M3
W=2
L=4
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 790 -630 0 0 {name=M4
W=2
L=4
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 540 -490 0 1 {name=M5
W=4
L=4
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 790 -490 0 0 {name=M6
W=4
L=4
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1010 -320 0 0 {name=M7
W=10
L=4
body=GND
nf=1
mult=16
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 790 -320 0 0 {name=M10
W=10
L=4
body=GND
nf=1
mult=4
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_stdcells/nand2_1.sym} 1490 -390 0 0 {name=x1 VGND=GNDA VNB=GNDA VPB=AVDDH VPWR=AVDDH prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1370 -410 0 0 {name=x2 VGND=GNDA VNB=GNDA VPB=AVDDH VPWR=AVDDH prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} 1170 -250 0 0 {name=p1 sig_type=std_logic lab=AVDDH
}
C {lab_pin.sym} 730 -380 0 0 {name=p2 sig_type=std_logic lab=MN_TAIL_BIAS}
C {/home/nithin/eda/LPCAS_TTSKY26a/Res_70K.sym} 780 -200 0 0 {name=x4}
C {sky130_fd_pr/pfet3_01v8.sym} 290 -490 0 1 {name=M13
W=8
L=4
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 290 -320 0 1 {name=M14
W=9
L=4
body=GND
nf=1
mult=4
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 620 -550 2 0 {name=p3 sig_type=std_logic lab=VBP_TOP}
C {lab_pin.sym} 660 -460 2 0 {name=p4 sig_type=std_logic lab=VBP_CASC}
C {/home/nithin/eda/LPCAS_TTSKY26a/Gm_STRP_N_BOT.sym} 990 -260 0 0 {name=x5
}
C {/home/nithin/eda/LPCAS_TTSKY26a/Res_70K.sym} 1380 -640 0 0 {name=x6
}
C {sky130_fd_pr/pfet3_01v8.sym} 1610 -390 0 0 {name=M12
W=0.5
L=4
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {iopin.sym} 180 -730 2 0 {name=p5 lab=AVDDH}
C {iopin.sym} 180 -110 2 0 {name=p6 lab=GNDA}
C {lab_pin.sym} 1700 -640 2 0 {name=p7 sig_type=std_logic lab=GNDA
}
C {vsource.sym} 80 -210 0 0 {name=V1 value=0 savecurrent=false}
C {vsource.sym} -20 -210 0 0 {name=V2 value=1.8 savecurrent=false}
C {gnd.sym} 80 -150 0 0 {name=l1 lab=0}
C {gnd.sym} -20 -150 0 0 {name=l2 lab=0}
C {lab_pin.sym} -20 -270 0 0 {name=p8 sig_type=std_logic lab=AVDDH }
C {lab_pin.sym} 80 -270 0 0 {name=p9 sig_type=std_logic lab=GNDA}
C {code.sym} -90 -410 0 0 {name=SAVE_COMM only_toplevel=false value="
.save @m.xm1.msky130_fd_pr__nfet_01v8[gm]
.save @m.xm1.msky130_fd_pr__nfet_01v8[gds]
.save @m.xm1.msky130_fd_pr__nfet_01v8[vth]
.save @m.xm1.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.xm1.msky130_fd_pr__nfet_01v8[cgg]
.save @m.xm1.msky130_fd_pr__nfet_01v8[cgso]
.save @m.xm1.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.xm3.msky130_fd_pr__pfet_01v8_lvt[gm]
.save @m.xm3.msky130_fd_pr__pfet_01v8_lvt[gds]
.save @m.xm3.msky130_fd_pr__pfet_01v8_lvt[vth]
.save @m.xm3.msky130_fd_pr__pfet_01v8_lvt[vdsat]
.save @m.xm3.msky130_fd_pr__pfet_01v8_lvt[cgg]
.save @m.xm3.msky130_fd_pr__pfet_01v8_lvt[cgso]
.save @m.xm3.msky130_fd_pr__pfet_01v8_lvt[cgdo]
.save @m.xm4.msky130_fd_pr__pfet_01v8_lvt[gm]
.save @m.xm4.msky130_fd_pr__pfet_01v8_lvt[gds]
.save @m.xm4.msky130_fd_pr__pfet_01v8_lvt[vth]
.save @m.xm4.msky130_fd_pr__pfet_01v8_lvt[vdsat]
.save @m.xm4.msky130_fd_pr__pfet_01v8_lvt[cgg]
.save @m.xm4.msky130_fd_pr__pfet_01v8_lvt[cgso]
.save @m.xm4.msky130_fd_pr__pfet_01v8_lvt[cgdo]
.save @m.xm5.msky130_fd_pr__pfet_01v8_lvt[gm]
.save @m.xm5.msky130_fd_pr__pfet_01v8_lvt[gds]
.save @m.xm5.msky130_fd_pr__pfet_01v8_lvt[vth]
.save @m.xm5.msky130_fd_pr__pfet_01v8_lvt[vdsat]
.save @m.xm5.msky130_fd_pr__pfet_01v8_lvt[cgg]
.save @m.xm5.msky130_fd_pr__pfet_01v8_lvt[cgso]
.save @m.xm5.msky130_fd_pr__pfet_01v8_lvt[cgdo]
.save @m.xm6.msky130_fd_pr__pfet_01v8_lvt[gm]
.save @m.xm6.msky130_fd_pr__pfet_01v8_lvt[gds]
.save @m.xm6.msky130_fd_pr__pfet_01v8_lvt[vth]
.save @m.xm6.msky130_fd_pr__pfet_01v8_lvt[vdsat]
.save @m.xm6.msky130_fd_pr__pfet_01v8_lvt[cgg]
.save @m.xm6.msky130_fd_pr__pfet_01v8_lvt[cgso]
.save @m.xm6.msky130_fd_pr__pfet_01v8_lvt[cgdo]
.save @m.xm7.msky130_fd_pr__nfet_01v8[gm]
.save @m.xm7.msky130_fd_pr__nfet_01v8[gds]
.save @m.xm7.msky130_fd_pr__nfet_01v8[vth]
.save @m.xm7.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.xm7.msky130_fd_pr__nfet_01v8[cgg]
.save @m.xm7.msky130_fd_pr__nfet_01v8[cgso]
.save @m.xm7.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.xm10.msky130_fd_pr__nfet_01v8[gm]
.save @m.xm10.msky130_fd_pr__nfet_01v8[gds]
.save @m.xm10.msky130_fd_pr__nfet_01v8[vth]
.save @m.xm10.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.xm10.msky130_fd_pr__nfet_01v8[cgg]
.save @m.xm10.msky130_fd_pr__nfet_01v8[cgso]
.save @m.xm10.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.xm13.msky130_fd_pr__pfet_01v8[gm]
.save @m.xm13.msky130_fd_pr__pfet_01v8[gds]
.save @m.xm13.msky130_fd_pr__pfet_01v8[vth]
.save @m.xm13.msky130_fd_pr__pfet_01v8[vdsat]
.save @m.xm13.msky130_fd_pr__pfet_01v8[cgg]
.save @m.xm13.msky130_fd_pr__pfet_01v8[cgso]
.save @m.xm13.msky130_fd_pr__pfet_01v8[cgdo]
.save @m.xm14.msky130_fd_pr__nfet_01v8[gm]
.save @m.xm14.msky130_fd_pr__nfet_01v8[gds]
.save @m.xm14.msky130_fd_pr__nfet_01v8[vth]
.save @m.xm14.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.xm14.msky130_fd_pr__nfet_01v8[cgg]
.save @m.xm14.msky130_fd_pr__nfet_01v8[cgso]
.save @m.xm14.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.x5.xm12.msky130_fd_pr__nfet_01v8[gm]
.save @m.x5.xm12.msky130_fd_pr__nfet_01v8[gds]
.save @m.x5.xm12.msky130_fd_pr__nfet_01v8[vth]
.save @m.x5.xm12.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.x5.xm12.msky130_fd_pr__nfet_01v8[cgg]
.save @m.x5.xm12.msky130_fd_pr__nfet_01v8[cgso]
.save @m.x5.xm12.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.x5.xm1.msky130_fd_pr__nfet_01v8[gm]
.save @m.x5.xm1.msky130_fd_pr__nfet_01v8[gds]
.save @m.x5.xm1.msky130_fd_pr__nfet_01v8[vth]
.save @m.x5.xm1.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.x5.xm1.msky130_fd_pr__nfet_01v8[cgg]
.save @m.x5.xm1.msky130_fd_pr__nfet_01v8[cgso]
.save @m.x5.xm1.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.x5.xm2.msky130_fd_pr__nfet_01v8[gm]
.save @m.x5.xm2.msky130_fd_pr__nfet_01v8[gds]
.save @m.x5.xm2.msky130_fd_pr__nfet_01v8[vth]
.save @m.x5.xm2.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.x5.xm2.msky130_fd_pr__nfet_01v8[cgg]
.save @m.x5.xm2.msky130_fd_pr__nfet_01v8[cgso]
.save @m.x5.xm2.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.x5.xm3.msky130_fd_pr__nfet_01v8[gm]
.save @m.x5.xm3.msky130_fd_pr__nfet_01v8[gds]
.save @m.x5.xm3.msky130_fd_pr__nfet_01v8[vth]
.save @m.x5.xm3.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.x5.xm3.msky130_fd_pr__nfet_01v8[cgg]
.save @m.x5.xm3.msky130_fd_pr__nfet_01v8[cgso]
.save @m.x5.xm3.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.x5.xm4.msky130_fd_pr__nfet_01v8[gm]
.save @m.x5.xm4.msky130_fd_pr__nfet_01v8[gds]
.save @m.x5.xm4.msky130_fd_pr__nfet_01v8[vth]
.save @m.x5.xm4.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.x5.xm4.msky130_fd_pr__nfet_01v8[cgg]
.save @m.x5.xm4.msky130_fd_pr__nfet_01v8[cgso]
.save @m.x5.xm4.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.x5.xm5.msky130_fd_pr__nfet_01v8[gm]
.save @m.x5.xm5.msky130_fd_pr__nfet_01v8[gds]
.save @m.x5.xm5.msky130_fd_pr__nfet_01v8[vth]
.save @m.x5.xm5.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.x5.xm5.msky130_fd_pr__nfet_01v8[cgg]
.save @m.x5.xm5.msky130_fd_pr__nfet_01v8[cgso]
.save @m.x5.xm5.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.x5.xm6.msky130_fd_pr__nfet_01v8[gm]
.save @m.x5.xm6.msky130_fd_pr__nfet_01v8[gds]
.save @m.x5.xm6.msky130_fd_pr__nfet_01v8[vth]
.save @m.x5.xm6.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.x5.xm6.msky130_fd_pr__nfet_01v8[cgg]
.save @m.x5.xm6.msky130_fd_pr__nfet_01v8[cgso]
.save @m.x5.xm6.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.x5.xm7.msky130_fd_pr__nfet_01v8[gm]
.save @m.x5.xm7.msky130_fd_pr__nfet_01v8[gds]
.save @m.x5.xm7.msky130_fd_pr__nfet_01v8[vth]
.save @m.x5.xm7.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.x5.xm7.msky130_fd_pr__nfet_01v8[cgg]
.save @m.x5.xm7.msky130_fd_pr__nfet_01v8[cgso]
.save @m.x5.xm7.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.x5.xm8.msky130_fd_pr__nfet_01v8[gm]
.save @m.x5.xm8.msky130_fd_pr__nfet_01v8[gds]
.save @m.x5.xm8.msky130_fd_pr__nfet_01v8[vth]
.save @m.x5.xm8.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.x5.xm8.msky130_fd_pr__nfet_01v8[cgg]
.save @m.x5.xm8.msky130_fd_pr__nfet_01v8[cgso]
.save @m.x5.xm8.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.x5.xm9.msky130_fd_pr__nfet_01v8[gm]
.save @m.x5.xm9.msky130_fd_pr__nfet_01v8[gds]
.save @m.x5.xm9.msky130_fd_pr__nfet_01v8[vth]
.save @m.x5.xm9.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.x5.xm9.msky130_fd_pr__nfet_01v8[cgg]
.save @m.x5.xm9.msky130_fd_pr__nfet_01v8[cgso]
.save @m.x5.xm9.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.xm12.msky130_fd_pr__pfet_01v8[gm]
.save @m.xm12.msky130_fd_pr__pfet_01v8[gds]
.save @m.xm12.msky130_fd_pr__pfet_01v8[vth]
.save @m.xm12.msky130_fd_pr__pfet_01v8[vdsat]
.save @m.xm12.msky130_fd_pr__pfet_01v8[cgg]
.save @m.xm12.msky130_fd_pr__pfet_01v8[cgso]
.save @m.xm12.msky130_fd_pr__pfet_01v8[cgdo]
.save @m.xm15.msky130_fd_pr__pfet_01v8[gm]
.save @m.xm15.msky130_fd_pr__pfet_01v8[gds]
.save @m.xm15.msky130_fd_pr__pfet_01v8[vth]
.save @m.xm15.msky130_fd_pr__pfet_01v8[vdsat]
.save @m.xm15.msky130_fd_pr__pfet_01v8[cgg]
.save @m.xm15.msky130_fd_pr__pfet_01v8[cgso]
.save @m.xm15.msky130_fd_pr__pfet_01v8[cgdo]
.save @m.xm16.msky130_fd_pr__nfet_01v8[gm]
.save @m.xm16.msky130_fd_pr__nfet_01v8[gds]
.save @m.xm16.msky130_fd_pr__nfet_01v8[vth]
.save @m.xm16.msky130_fd_pr__nfet_01v8[vdsat]
.save @m.xm16.msky130_fd_pr__nfet_01v8[cgg]
.save @m.xm16.msky130_fd_pr__nfet_01v8[cgso]
.save @m.xm16.msky130_fd_pr__nfet_01v8[cgdo]
.save @m.xm8.msky130_fd_pr__pfet_01v8_lvt[gm]
.save @m.xm8.msky130_fd_pr__pfet_01v8_lvt[gds]
.save @m.xm8.msky130_fd_pr__pfet_01v8_lvt[vth]
.save @m.xm8.msky130_fd_pr__pfet_01v8_lvt[vdsat]
.save @m.xm8.msky130_fd_pr__pfet_01v8_lvt[cgg]
.save @m.xm8.msky130_fd_pr__pfet_01v8_lvt[cgso]
.save @m.xm8.msky130_fd_pr__pfet_01v8_lvt[cgdo]
.save @m.xm9.msky130_fd_pr__pfet_01v8_lvt[gm]
.save @m.xm9.msky130_fd_pr__pfet_01v8_lvt[gds]
.save @m.xm9.msky130_fd_pr__pfet_01v8_lvt[vth]
.save @m.xm9.msky130_fd_pr__pfet_01v8_lvt[vdsat]
.save @m.xm9.msky130_fd_pr__pfet_01v8_lvt[cgg]
.save @m.xm9.msky130_fd_pr__pfet_01v8_lvt[cgso]
.save @m.xm9.msky130_fd_pr__pfet_01v8_lvt[cgdo]
.save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[gm]
.save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[gds]
.save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[vth]
.save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[vdsat]
.save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[cgg]
.save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[cgso]
.save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[cgdo]
.save @m.xm11.msky130_fd_pr__pfet_01v8_lvt[gm]
.save @m.xm11.msky130_fd_pr__pfet_01v8_lvt[gds]
.save @m.xm11.msky130_fd_pr__pfet_01v8_lvt[vth]
.save @m.xm11.msky130_fd_pr__pfet_01v8_lvt[vdsat]
.save @m.xm11.msky130_fd_pr__pfet_01v8_lvt[cgg]
.save @m.xm11.msky130_fd_pr__pfet_01v8_lvt[cgso]
.save @m.xm11.msky130_fd_pr__pfet_01v8_lvt[cgdo]
"}
C {vsource.sym} 170 -210 0 0 {name=V3 value=1.8 savecurrent=false}
C {gnd.sym} 170 -150 0 0 {name=l3 lab=0}
C {lab_pin.sym} 170 -270 0 0 {name=p10 sig_type=std_logic lab=EN }
C {lab_pin.sym} 1330 -370 0 0 {name=p11 sig_type=std_logic lab=EN }
C {sky130_fd_pr/pfet3_01v8.sym} 650 -680 0 0 {name=M15
W=0.5
L=1
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_stdcells/inv_1.sym} 1450 -570 0 0 {name=x7 VGND=GNDA VNB=GNDA VPB=AVDDH VPWR=AVDDH prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} 1380 -570 0 0 {name=p12 sig_type=std_logic lab=EN }
C {lab_pin.sym} 1520 -570 2 0 {name=p13 sig_type=std_logic lab=EN_B
}
C {sky130_fd_pr/nfet3_01v8.sym} 650 -240 0 0 {name=M16
W=0.5
L=1
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 600 -240 0 0 {name=p14 sig_type=std_logic lab=EN_B}
C {lab_pin.sym} 580 -680 0 0 {name=p15 sig_type=std_logic lab=EN }
C {lab_pin.sym} 1080 -410 2 0 {name=p16 sig_type=std_logic lab=VOUT}
C {lab_pin.sym} 1260 -410 0 0 {name=p17 sig_type=std_logic lab=VSTRP_IP
}
C {lab_pin.sym} 1570 -390 1 0 {name=p18 sig_type=std_logic lab=VSTRP_OUT

}
C {ngspice_probe.sym} 520 -270 0 0 {name=r1}
C {ngspice_probe.sym} 520 -560 0 0 {name=r2}
C {ngspice_probe.sym} 810 -560 0 0 {name=r3}
C {ngspice_probe.sym} 1030 -560 0 0 {name=r4}
C {ngspice_probe.sym} 1030 -270 0 0 {name=r5}
C {ngspice_probe.sym} 1260 -570 0 0 {name=r6
}
C {devices/code_shown.sym} -90 -700 0 0 {name="NGSPICE" only_toplevel=true 
value="
.param A=10k Vos=0 VDD=1.8 VSS=0
.option wnflag=1 gmin=1e-18
.option savecurrents
.temp 27
.control
save all
op
write OTA_Gm_Cell.raw
set appendwrite 
**dc temp -40 140 10
**write OTA_Gm_Cell.raw
.endc
"}
C {devices/code.sym} 80 -410 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {devices/launcher.sym} 110 -590 0 0 {name=h15
descr="Annotate OP" 
tclcommand="set show_hidden_texts 1; xschem annotate_op"
}
C {sky130_fd_pr/annotate_fet_params.sym} 310 -290 0 0 {name=annot1 ref=M1}
C {sky130_fd_pr/annotate_fet_params.sym} 840 -270 0 0 {name=annot2 ref=M10}
C {lab_pin.sym} 350 -470 2 0 {name=p19 sig_type=std_logic lab=VBP_CASC}
C {sky130_fd_pr/annotate_fet_params.sym} 290 -700 0 0 {name=annot3 ref=M3}
C {ngspice_probe.sym} 350 -490 0 0 {name=r8}
C {/home/nithin/eda/LPCAS_TTSKY26a/Res_70K.sym} 270 -200 0 0 {name=x3}
C {ngspice_probe.sym} 1410 -410 0 0 {name=r9
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 1010 -630 0 0 {name=M8
W=2
L=4
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 1010 -490 0 0 {name=M9
W=4
L=4
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 1240 -630 0 0 {name=M2
W=2
L=4
body=VDD
nf=1
mult=7
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 1240 -490 0 0 {name=M11
W=4
L=4
body=VDD
nf=1
mult=7
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/annotate_fet_params.sym} 880 -470 0 0 {name=annot4 ref=M6}
C {ngspice_probe.sym} 520 -420 0 0 {name=r7}
C {sky130_fd_pr/annotate_fet_params.sym} 340 -430 0 0 {name=annot5 ref=M5}
C {sky130_fd_pr/nfet3_01v8.sym} 1780 -320 0 0 {name=M17
W=1
L=4
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 1820 -650 0 1 {name=M18
W=5
L=10
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {ngspice_probe.sym} 1800 -510 0 0 {name=r10}
C {sky130_fd_pr/nfet3_01v8.sym} 1950 -320 0 0 {name=M19
W=10
L=4
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 1990 -650 0 1 {name=M20
W=5
L=10
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {ngspice_probe.sym} 1970 -510 0 0 {name=r11}
C {lab_pin.sym} 1880 -590 2 0 {name=p20 sig_type=std_logic lab=VSCALE
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 2170 -650 0 0 {name=M21
W=1
L=10
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {lab_pin.sym} 2130 -650 0 0 {name=p21 sig_type=std_logic lab=VSCALE
}
C {sky130_fd_pr/nfet3_01v8.sym} 2170 -320 0 0 {name=M22
W=1
L=4
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {ngspice_probe.sym} 2190 -510 0 0 {name=r12}
C {sky130_fd_pr/nfet3_01v8.sym} 2490 -320 0 1 {name=M23
W=1
L=4
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {isource.sym} 2470 -550 0 0 {name=I0 value=500n}
C {sky130_fd_pr/nfet3_01v8.sym} 2640 -320 0 0 {name=M24
W=1
L=4
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 2680 -630 0 1 {name=M25
W=3
L=4
body=VDD
nf=1
mult=2
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 3000 -630 0 0 {name=M26
W=3
L=4
body=VDD
nf=1
mult=2
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3000 -320 0 0 {name=M27
W=0.5
L=4
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2860 -320 0 1 {name=M28
W=0.5
L=4
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {isource.sym} 2840 -470 0 0 {name=ISUB value=200n}
C {sky130_fd_pr/nfet3_01v8.sym} 3180 -320 0 1 {name=M29
W=1
L=4
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3310 -320 0 0 {name=M30
W=1
L=4
body=GND
nf=1
mult=5
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 3350 -630 0 1 {name=M31
W=4
L=4
body=VDD
nf=1
mult=7
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 3480 -630 0 0 {name=M32
W=4
L=4
body=VDD
nf=1
mult=6
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {ngspice_probe.sym} 2470 -420 0 0 {name=r14}
C {ngspice_probe.sym} 2660 -420 0 0 {name=r15}
C {ngspice_probe.sym} 2920 -390 0 0 {name=r16}
C {ngspice_probe.sym} 3160 -480 0 0 {name=r17}
C {ngspice_probe.sym} 3330 -480 0 0 {name=r18}
C {/home/nithin/eda/SC_Biquad_Filters_RAMP/Xschem/Ideal_Sources/Ideal-OPAMP.sym} 3460 -390 0 0 {name=x8}
C {res.sym} 3790 -540 1 0 {name=R20
value=100k
footprint=1206
device=resistor
m=1}
C {vsource.sym} 3610 -230 0 0 {name=V4 value=1 savecurrent=false}
C {lab_pin.sym} 4000 -390 2 0 {name=p22 sig_type=std_logic lab=Vout_Final}
C {res.sym} 3940 -270 0 0 {name=R13
value=100k
footprint=1206
device=resistor
m=1}
